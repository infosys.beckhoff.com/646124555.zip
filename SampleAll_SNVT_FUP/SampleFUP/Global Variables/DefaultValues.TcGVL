VAR_GLOBAL CONSTANT
	tMinSendTimeDefault  : TIME:=t#1000ms;
	tMaxSendTimeDefault  : TIME:=t#0s;
	bAutoDefault		 : BOOL:=FALSE;
	bSendInitDefault	 : BOOL:=FALSE;
END_VAR
